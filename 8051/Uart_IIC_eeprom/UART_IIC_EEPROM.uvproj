# Keil uVision project UART_IIC_EEPROM.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(33000000) MODP2
  output: UART_IIC_EEPROM +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c eeprom.c eeprom.h delay.c delay.h uart.c uart.h
