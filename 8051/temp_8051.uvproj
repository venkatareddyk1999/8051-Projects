# Keil uVision project temp_8051.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(33000000) MODP2
  output: temp_8051
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c lcd.h lcd.c adc.h adc.c IO_Definitions.h
